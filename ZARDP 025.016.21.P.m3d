# KOMPAS-3D part (ZARDP 025.016.21.P.m3d)

Model tree:
1. Плоскость XY
2. Плоскость ZX
3. Плоскость ZY
4. Ось X
5. Ось Y
6. Ось Z
7. Начало координат
8. Булева операция:3
9. Булева операция:5
10. Булева операция:6
11. Булева операция:7
